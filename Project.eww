<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\..\..\Desktop\EMBSYS100\Week6\EMBSYS100Week5Assignment\EWARM\EMBSYS100Week5Assignment.ewp</path>
    </project>
    <batchBuild />
</workspace>
