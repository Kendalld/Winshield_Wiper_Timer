<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Winshield_Wiper_Timer.ewp</path>
  </project>
  <batchBuild />
</workspace>
